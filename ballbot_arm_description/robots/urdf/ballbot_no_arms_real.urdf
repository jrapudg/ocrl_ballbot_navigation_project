Commit message: Add saved references

File: ballbot_arm_description/robots/urdf/ballbot_no_arms_real.urdf (robot description, URDF)
Before this commit: robot ballbot, 10 links, 9 joints
Links:
- link Link_Body: mass 71.34 -> 64.86
